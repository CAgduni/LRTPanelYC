PACKAGECONFIG="opengl egl dri gles gallium etnaviv"
FILES_${PN} += "${libdir}/*"
